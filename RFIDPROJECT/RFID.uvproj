# Keil uVision project RFID.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89S52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODP2
  output: RFID +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: ..\RFIDPROJECT
  group Source Group 1
    ./: STARTUP.A51 rfid_program_code.c
